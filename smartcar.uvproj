# Keil uVision project smartcar.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: smartcar +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./user/: ADC.c delay.c main.c pwm.c timer.c OLED_SPI_hardware.c
